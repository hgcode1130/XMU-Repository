DATAS SEGMENT
	X DB 5
DATAS ENDS
STACK SEGMENT
	
STACK ENDS
	
CODES SEGMENT
	ASSUME CS:CODES,DS:DATAS,SS:STACK
START:
MAIN:
	MOV AX,DATAS
	MOV DS,AX
	MOV AX,2;����5��ƽ��
	CALL FACT
	MOV BX,DX
	
	MOV AH,4CH
	INT 21H
FACT PROC
	CMP AL,0;AL������
	JNE IIA
	MOV DL,1
	RET
IIA:
	DEC AL
	CALL FACT
X2:
	CALL MULT
X3:
	MOV DX,AX
	RET
FACT ENDP

MULT PROC
	MOV AL,DL;��X
	MUL X
	RET
MULT ENDP
CODES ENDS
	END START
