DATAS SEGMENT
	W DB 14H
	ARRAY DB 1h,2h,3h,5h,6h,8h,9h,10h,15h,20h
DATAS ENDS

STACK SEGMENT
	
STACK ENDS
	
CODES SEGMENT
	ASSUME CS:CODES,DS:DATAS,SS:STACK
START:
MAIN:
	MOV AX,DATAS
	MOV DS,AX
	CALL FACT
	MOV AH,4CH
	INT 21H
FACT PROC
	MOV CX,10;设置循环次数
	MOV BX,0
	MOV AX,-1
Looop:
	INC AX
	MOV SI,AX
	MOV BL,[ARRAY+SI]
	CMP BL,W
	JE case1;找到跳转
	JG case2;大于说明不存在
	LOOP Looop
	JMP case2
case1:
	MOV AH,02
	MOV DL,'Y'
	INT 21H
	RET
case2:
	push AX
	ADD AX, CX
lop:;通过循环将数组元素后挪
	SUB AX,1h
	MOV SI,AX
	MOV BL,[ARRAY+SI]
	MOV [ARRAY+SI+1],BL
	LOOP lop
	MOV BL,W
	pop SI
	MOV [ARRAY+SI],BL;存入
	RET
FACT ENDP
CODES ENDS
	END START




