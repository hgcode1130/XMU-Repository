DATAS SEGMENT
	BUFFER DB 'DEBUGDEBUGDE'
	STRING1 DB 'NO FINDING!','$'
	STRING2 DW 0000H,'$'
DATAS ENDS

STACK SEGMENT
	
STACK ENDS
	
CODES SEGMENT
	ASSUME CS:CODES,DS:DATAS,SS:STACK
START:
MAIN:
	MOV AX,DATAS
	MOV DS,AX
	MOV CX,12;循环次数为buffer长度
	MOV SI,-1
looop:
	MOV AX,0
	INC SI;每次前进1字节
	CALL FACT
	CMP AX,1; 存在跳转
	JE NEXT
	LOOP looop
	MOV AH,09H;不存在输出字符串
	MOV DX,OFFSET STRING1
	INT 21H
	JMP OUT1
NEXT:
	MOV AX,SI
	MOV STRING2,AX;存入‘D’的下标
	MOV AH,09H
	MOV DX,OFFSET STRING2
	INT 21H
OUT1:
	MOV AH,4CH
	INT 21H
FACT PROC
	MOV BL,[BUFFER+SI];检查字符是否相同
	CMP BL,'D'
	JNE case
	MOV BL,[BUFFER+SI+1]
	CMP BL,'E'
	JNE case
	MOV BL,[BUFFER+SI+2]
	CMP BL,'B'
	JNE case
	MOV BL,[BUFFER+SI+3]
	CMP BL,'U'
	JNE case
	MOV BL,[BUFFER+SI+4]
	CMP BL,'G'
	JNE case
	MOV AX,1;无中途退出，存在
	RET
case:
	MOV AX,0
	RET
FACT ENDP
CODES ENDS
	END START


