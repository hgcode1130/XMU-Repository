DATAS SEGMENT
    ;此处输入数据段代码 
	X DW 200h ; X 初始值为 200
    Y DW 300h ; Y 初始值为 300
    Z DW 400h ; Z 初始值为 400
    V DW 500h ; V 初始值为 500
DATAS ENDS

STACKS SEGMENT
    ;此处输入堆栈段代码
STACKS ENDS

CODES SEGMENT
    ASSUME CS:CODES,DS:DATAS,SS:STACKS
START:
    MOV AX,DATAS
    MOV DS,AX
    ;此处输入代码段代码
    
    MOV AX,DATAS
	MOV DS,AX
	MOV AX,WORD PTR X
	MOV BX,WORD PTR Y
	IMUL BX
	MOV CX,AX
	MOV BX,DX
	MOV AX,WORD PTR Z
	CWD
	ADD CX,AX
	ADC BX,DX
	SUB CX,0540H
	SBB BX,0
	MOV AX,WORD PTR V
	CWD
	SUB AX,CX
	SBB DX,BX
	MOV BX,WORD PTR X
	IDIV BX

    MOV AH,4CH
    INT 21H
CODES ENDS
    END START
